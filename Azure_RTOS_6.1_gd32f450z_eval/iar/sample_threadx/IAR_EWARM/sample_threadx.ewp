# IAR project sample_threadx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F450xK GD GD32F450xK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: GD32F450; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\gd32f450_lib\Firmware\CMSIS; ..\..\gd32f450_lib\Firmware\CMSIS\GD\GD32F4xx\Include; ..\..\gd32f450_lib\Firmware\GD32F4xx_standard_peripheral\Include; ..\..\gd32f450_lib\Utilities; ..\..\threadx\common\inc; ..\..\threadx\ports\cortex_m4\iar\inc; ..\..\gd32f450_lib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: sample_threadx.out
  ILINK.IlinkIcfFile: ..\..\common_hardware_code\GD32F450xK.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Common_source
    ../../common_hardware_code/: board_setup.c startup_gd32f450.s tx_initialize_low_level.s
  group Lib
    ../../gd32f450_lib/Debug/Exe/: gd32f450_lib.a
    ../../threadx/IAR_EWARM/Debug/Exe/: threadx.a
  group Sample
    ../: sample_threadx.c
