# IAR project gd32f450_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F450; MQTTCLIENT_PLATFORM_HEADER=MQTTCMSIS.h; ENABLE_IOT_INFO; ENABLE_IOT_ERROR; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; SENSOR; RFU
  ICCARM.CCIncludePath2: Firmware\CMSIS; Firmware\CMSIS\GD\GD32F4xx\Include; Firmware\GD32F4xx_standard_peripheral\Include; Utilities; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: gd32f450_lib.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group GD32F4xx_standard_peripheral
    Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Utilities
    Utilities/: gd32f450z_eval.c gd32f4xx_enet_eval.c
