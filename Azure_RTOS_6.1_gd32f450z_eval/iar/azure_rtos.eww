<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\gd32f450_lib\gd32f450_lib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\netxduo\IAR_EWARM\netxduo.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\sample_azure_iot_embedded_sdk\IAR_EWARM\sample_azure_iot_embedded_sdk.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\sample_azure_iot_embedded_sdk_pnp\IAR_EWARM\sample_azure_iot_embedded_sdk_pnp.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\sample_netx_duo_ping\IAR_EWARM\sample_netx_duo_ping.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\sample_pnp_temperature_controller\IAR_EWARM\sample_pnp_temperature_controller.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\sample_threadx\IAR_EWARM\sample_threadx.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\threadx\IAR_EWARM\threadx.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>Azure_RTOS_GD32F450Z</name>
            <member>
                <project>gd32f450_lib</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>netxduo</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_azure_iot_embedded_sdk</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_azure_iot_embedded_sdk_pnp</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_netx_duo_ping</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_pnp_temperature_controller</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sample_threadx</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>threadx</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
