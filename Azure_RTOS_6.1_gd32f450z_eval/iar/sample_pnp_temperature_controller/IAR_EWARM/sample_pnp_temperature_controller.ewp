# IAR project sample_pnp_temperature_controller.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F450xK GD GD32F450xK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: GD32F450; USE_STDPERIPH_DRIVER; NX_SECURE_ENABLE; NXD_MQTT_CLOUD_ENABLE; NX_ENABLE_IP_PACKET_FILTER; SAMPLE_DHCP_DISABLE
  ICCARM.CCIncludePath2: ..\inc; ..\..\netxduo\common\inc; ..\..\netxduo\ports\cortex_m4\iar\inc; ..\..\netxduo\addons\azure_iot\azure-sdk-for-c\sdk\inc; ..\..\netxduo\addons\azure_iot; ..\..\netxduo\addons\azure_iot\azure_iot_security_module; ..\..\netxduo\addons\azure_iot\azure_iot_security_module\inc; ..\..\netxduo\addons\azure_iot\azure_iot_security_module\iot-security-module-core\inc; ..\..\netxduo\addons\azure_iot\azure_iot_security_module\iot-security-module-core\deps\flatcc\include; ..\..\netxduo\addons\azure_iot\azure_iot_security_module\iot-security-module-core\deps\flatcc\src\runtime; ..\..\netxduo\crypto_libraries\inc; ..\..\netxduo\nx_secure\inc; ..\..\netxduo\nx_secure\ports; ..\..\netxduo\addons\cloud; ..\..\netxduo\addons\dhcp; ..\..\netxduo\addons\dns; ..\..\netxduo\addons\mqtt; ..\..\netxduo\addons\sntp; ..\..\gd32f450_lib\Firmware\CMSIS; ..\..\gd32f450_lib\Firmware\CMSIS\GD\GD32F4xx\Include; ..\..\gd32f450_lib\Firmware\GD32F4xx_standard_peripheral\Include; ..\..\gd32f450_lib\Utilities; ..\..\gd32f450_lib; ..\..\threadx\ports\cortex_m4\iar\inc; ..\..\threadx\common\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: sample_pnp_temperature_controller.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Common_source
    ../../common_hardware_code/: board_setup.c nx_driver_gd32f450zk.c startup_gd32f450.s tx_initialize_low_level.s
  group Lib
    ../../gd32f450_lib/Debug/Exe/: gd32f450_lib.a
    ../../netxduo/IAR_EWARM/Debug/Exe/: netxduo.a
    ../../threadx/IAR_EWARM/Debug/Exe/: threadx.a
  group Sample
    ../src/: main.c nx_azure_iot_cert.c nx_azure_iot_ciphersuites.c nx_azure_iot_pnp_helpers.c sample_device_identity.c sample_pnp_deviceinfo_component.c sample_pnp_temperature_controller.c sample_pnp_thermostat_component.c
